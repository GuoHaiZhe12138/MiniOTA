# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MiniOta +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Star;.\User;.\Library;.\MiniOTA\ota_interface;.\MiniOTA\ota_src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Star
    ./Star/: startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h core_cm3.c core_cm3.h
  group User
    ./: main.c
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Delay.c Delay.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h
  group MiniOTA
    ./MiniOTA/ota_src/: OtaUtils.h OtaFlash.h OtaJump.h OtaXmodem.h OtaCore.c OtaPort.c OtaJump.c OtaUtils.c OtaFlash.c OtaXmodem.c OtaFlashIfoDef.h
    ./MiniOTA/ota_interface/: OtaInterface.h OtaPort.h stm32f103_md.h
